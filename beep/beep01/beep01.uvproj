# Keil uVision project beep01.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: beep01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 beep01.c io51.h
    //VBOXSVR/vboxshare/hw_8x51/beep/beep01/: s51pgm.h
