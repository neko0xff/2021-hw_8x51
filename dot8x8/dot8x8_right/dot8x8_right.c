/*
* File: dot8x8.c
* 功能: 令 8X8 單色點矩陣週而復始左起右移的依序顯示 0～9
*/

#include "io51.h"
/*8*8點距陣(0~9)顯示碼*/
code char dot8x8[80]={
   0xff,0x81,0x7a,0x79,0x6e,0x5e,0x81,0xff, /*0*/
	 0xff,0x7f,0x7f,0x00,0x7d,0x7f,0x7f,0xff, /*1*/
	 0xff,0x71,0x6e,0x6e,0x6e,0x6e,0x1d,0xff, /*2*/
	 0xff,0x89,0x76,0x76,0x76,0x71,0xbd,0xff, /*3*/
	 0xff,0xef,0x00,0xef,0xee,0xed,0xe3,0xff, /*4*/
	 0xff,0x8e,0x76,0x76,0x76,0x76,0xb0,0xff, /*5*/
	 0xff,0x8d,0x76,0x76,0x76,0x76,0x81,0xff, /*6*/
	 0xff,0xfc,0xfa,0x06,0xfe,0xfe,0xfc,0xff, /*7*/
	 0xff,0x89,0x76,0x76,0x76,0x76,0x89,0xff, /*8*/
	 0xff,0x81,0x6e,0x6e,0x6e,0x6e,0xb1,0xff  /*9*/
};
char buf[8]; //緩衝器
void delay(int x);
void shift_right();

/*主程式*/
void main(){
   int i,j,k;

   /*清除存放右移資料的buf[8]*/
   for(i=0;i<8;i++) buf[i]=0xFF; 

   while(1){
       for(i=0;i<8*10;i++){
           /*把右移資料分別存在buf[]中*/
           for(j=0;j<7;j++) buf[j]= buf[j+1];
           
				   /*把亮法加入至右移資料*/
				   buf[j]= dot8x8[i];
           
           /*重復掃描各字型50回(增加亮度)*/
           for(k=0;k<50;k++) shift_right(); //字型右移
       }
   }
}

/*call 右移的副程式*/
void shift_right(){
    int i;
    int enable_signal=0x80;//致能=0x01

    /*各字型由8筆資料組成=掃8回*/
    for(i=0;i<8;i++){
		/*把右移資料分別存在buf[]中*/
        P1=buf[i];
        P2=enable_signal;
        delay(50); //delay 50ms=0.05sec
        enable_signal>>=1; //右移1個位元
    }
}

/*delay time*/
void delay(int x){
    int m;
    for(m=0;m<x;m++);
}